# Keil uVision project secondary_mcu.uvprojx, settings and files
target secondary_mcu_rtos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: secondary_mcu_rtos +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC,HID_ENDPOINT
  c include: ..\CMSIS;..\DRIVER;..\FREERTOS\include;..\FREERTOS\portable\RVDS\ARM_CM4F;..\STM32F4xx_HAL_Driver\Inc;..\SYSTEM;..\USB\hid;..\USB\STM32_USB_Device_Library\Class\CustomHID\Inc;..\USB\STM32_USB_Device_Library\Core\Inc;..\USB\USB_DEVICE;..\TASK;..\MODULE
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group driver
    ../DRIVER/: steering_pwm.c main_serial.c second_serial.c soft_serial_send.c soft_serial_tim3.c soft_serial_tim4.c soft_serial_tim5.c
  group freertos
    ../FREERTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FREERTOS/portable/MemMang/: heap_4.c
    ../FREERTOS/portable/RVDS/ARM_CM4F/: port.c
  group module
    ../MODULE/: circ_buf.c
  group stlib
    ../STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group system
    ../SYSTEM/: main.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c system_stm32f4xx.c
    ../CMSIS/: startup_stm32f401xc.s
  group task
    ../TASK/: steering_task.c steering_action_task.c steering_updata_task.c
  group usb
    ../USB/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
    ../USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../USB/USB_DEVICE/: usb_device.c usbd_conf.c usbd_custom_hid_if.c usbd_desc.c
